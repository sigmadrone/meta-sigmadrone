include u-boot-colibri.inc

PV = "v2015.10+git${SRCPV}"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=0507cd7da8e7ad6d6701926ec9b84c95"
SRCREV = "e621ee96d735664971ce1f508127bc7f5a253458"
SRCBRANCH = "colibri-2015.10"
