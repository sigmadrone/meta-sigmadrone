include u-boot-colibri.inc

PV = "v2014.10+git${SRCPV}"

SRCREV = "a2137086bea0259812314f262e20c704729bba09"
SRCBRANCH = "colibri-2014.10"
