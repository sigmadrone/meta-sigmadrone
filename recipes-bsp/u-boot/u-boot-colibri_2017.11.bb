include u-boot-colibri.inc

PV = "v2017.11+git${SRCPV}"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=a2c678cfd4a4d97135585cad908541c6"
SRCREV = "a659b6fc6415245ecd521dc356bc52dc752bad16"
SRCBRANCH = "colibri-2017.11"
